# Repository MazinLab/huskypointofload (continued)

## KiCad design huskypointofload.kicad_pcb (continued)

Schematic: lmk04828.kicad_sch

Parts:
C69, C81: 10u; C_0603_1608Metric; DIGIKEY_PN 490-10727-1-ND
C70, C82: 4.7u; C_1206_3216Metric; DIGIKEY_PN 490-GRM31CZ72A475ME11LCT-ND
C71: 0.68n; C_0402_1005Metric
C72, C73, C74, C75, C76, C77, C78, C83, C84, C85, C86, C87, C88, C89: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
C79, C80: 100p; C_0402_1005Metric
C90, C92, C93, C94, C95, C96, C97, C98, C103, C104, C105, C107, C108, C109: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
C91, C106, C110: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND; not fitted
C99: 22p; C_0402_1005Metric
C100: 2.2n; C_0402_1005Metric
C101: 10u; C_0402_1005Metric
C102: 100n; C_0402_1005Metric
J26: SYNC; WR-MMCX_Wuerth_66012102111404_Vertical
J27: REF; WR-MMCX_Wuerth_66012102111404_Vertical
JP1: SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R66, R68, R81, R86, R87, R93, R96: 0; R_0402_1005Metric
R67: 39k; R_0402_1005Metric
R69, R99: 100; R_0402_1005Metric; not fitted
R70, R71: 120; R_0402_1005Metric; not fitted
R72, R73, R94: 0; R_0402_1005Metric; not fitted
R74, R101, R102, R103, R104, R105, R106, R107, R108, R109: 4.7k; R_0402_1005Metric; DIGIKEY_PN 311-4.7KJRCT-ND
R75, R88: 150; R_0402_1005Metric
R76, R91: 150; R_0402_1005Metric; not fitted
R77, R78, R90, R92, R95: 49.9; R_0402_1005Metric
R79, R97: 453k; R_0402_1005Metric; DIGIKEY_PN 13-RC0402FR-13453KLCT-ND
R80, R98: 33k; R_0402_1005Metric; DIGIKEY_PN YAG4374CT-ND
R82: 38.3; R_0402_1005Metric
R83: 38.3; R_0402_1005Metric; not fitted
R84, R89, R111, R113, R115, R117: 240; R_0402_1005Metric; not fitted
R85: 49.9; R_0402_1005Metric; not fitted
R100: 2.7k; R_0402_1005Metric
R110, R112, R114, R116: 240; R_0402_1005Metric
TP9: BACKUP; TestPoint_Keystone_5015_Micro_Mini; DIGIKEY_PN 36-5015CT-ND
U18: XX-XXX-VVXXFFF.fffff; Oscillator_SMD_6Pin_9x14mm
U19: LMK0482x; QFN-64_EP_9x9_Pitch0.5mm_EP7.2
Y3: ASE-xxxMHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3.3VA_LMKDIG: C69.1, C70.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, R79.1, R101.1; also elsewhere on the board
/Clocking/BACKUP_DIS: R72.1, R73.1, R74.2, TP9.1 (1_1), Y3.1 (EN); also elsewhere on the board
/Clocking/LD1: R106.1; also elsewhere on the board
/Clocking/LD2: R107.1; also elsewhere on the board
/Clocking/LMK04828/+3.3VA_LMKCGVCO: C81.1, C82.1, C83.1, C84.1, C85.1, C86.1, C87.1, C88.1, C89.1, R97.1; also elsewhere on the board
/Clocking/LMK04828/CP: R66.1, U19.32 (CP_{1})
/Clocking/LMK04828/DCLK0n: C104.2; also elsewhere on the board
/Clocking/LMK04828/DCLK0p: C103.2; also elsewhere on the board
/Clocking/LMK04828/DCLK2n: C108.2; also elsewhere on the board
/Clocking/LMK04828/DCLK2p: C107.2; also elsewhere on the board
/Clocking/LMK04828/HF Out 2/C+: U19.24 (DCLK4_{P}); also elsewhere on the board
/Clocking/LMK04828/HF Out 2/C-: U19.25 (DCLK4_{N}); also elsewhere on the board
/Clocking/LMK04828/HF Out 3/C+: U19.22 (SDCLK5_{P}); also elsewhere on the board
/Clocking/LMK04828/HF Out 3/C-: U19.23 (SDCLK5_{N}); also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 9/C+: U19.49 (SDCLK9_{P}); also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 9/C-: U19.50 (SDCLK9_{N}); also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 10/C+: U19.54 (DCLK10_{P}); also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 10/C-: U19.55 (DCLK10_{N}); also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 11/C+: U19.56 (SDCLK11_{P}); also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 11/C-: U19.57 (SDCLK11_{N}); also elsewhere on the board
/Clocking/LMK04828/Linear POL LMK DIG/PGFB: R79.2; also elsewhere on the board
/Clocking/LMK04828/Linear POL LMK DIG/SET: R80.1; also elsewhere on the board
/Clocking/LMK04828/Linear POL LMK VCO/PGFB: R97.2; also elsewhere on the board
/Clocking/LMK04828/Linear POL LMK VCO/SET: R98.1; also elsewhere on the board
/Clocking/LMK04828/OSCIN_N: C98.1, U19.44 (OSCIN_{N})
/Clocking/LMK04828/OSCIN_P: C97.2, U19.43 (OSCIN_{P})
/Clocking/LMK04828/OSC_N: C91.1, R69.2, R71.1, U18.5 (OUT-)
/Clocking/LMK04828/OSC_P: C90.1, R69.1, R70.1, U18.4 (OUT+)
/Clocking/LMK04828/SDCLK1n: C106.2
/Clocking/LMK04828/SDCLK1p: C105.2; also elsewhere on the board
/Clocking/LMK04828/SDCLK3n: C110.2
/Clocking/LMK04828/SDCLK3p: C109.2; also elsewhere on the board
/Clocking/LMK04828/SEL0: R72.2, R108.1; also elsewhere on the board
/Clocking/LMK04828/SEL1: R73.2, R109.1; also elsewhere on the board
/Clocking/LMK04828/VCC_CG0: C83.3, U19.64 (VCC12_{CG0})
/Clocking/LMK04828/VCC_CG1: C84.3, U19.17 (VCC2_{CG1})
/Clocking/LMK04828/VCC_CG2: C85.3, U19.26 (VCC4_{CG2})
/Clocking/LMK04828/VCC_CG3: C86.3, U19.53 (VCC11_{CG3})
/Clocking/LMK04828/VCC_CP2: C77.3, U19.45 (VCC9_{CP2})
/Clocking/LMK04828/VCC_DIG: C73.3, U19.33 (VCC5_{DIG})
/Clocking/LMK04828/VCC_OSCIN: C76.3, U19.42 (VCC8_{OSCIN})
/Clocking/LMK04828/VCC_OSCOUT: C75.3, U19.39 (VCC7_{OSCOUT})
/Clocking/LMK04828/VCC_OSC_BACK: C89.3, R74.1, Y3.4 (Vdd)
/Clocking/LMK04828/VCC_PLL1: C74.3, U19.36 (VCC6_{PLL1})
/Clocking/LMK04828/VCC_PLL2: C78.3, U19.47 (VCC10_{PLL2})
/Clocking/LMK04828/VCC_SYSREF: C72.3, U19.21 (VCC3_{SYSREF})
/Clocking/LMK04828/VCC_VCO: C87.3, U19.10 (VCC1_{VCO})
/Clocking/LMK04828/VCC_VCXO: C88.3, U18.6 (VDD)
/Clocking/LMK04828/VTUNE: C71.1, C79.1, R66.2, R68.1
/Clocking/LMKRESET: R105.1; also elsewhere on the board
/Clocking/~LMKCS: R101.2, R102.1; also elsewhere on the board
/Recieve Chain/CIPO: R104.1; also elsewhere on the board
/Recieve Chain/SCK: R103.1; also elsewhere on the board
GND: C69.2, C70.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C94.2, C96.2, C99.2, C101.2, C102.2, J26.2 (Ext), J27.2 (Ext), JP1.1 (A), R67.2, R70.2, R71.2, R75.2, R76.2, R77.2, R78.2, R80.2, R84.2, R85.2, R88.2, R89.2, R90.2, R91.2, R92.2, R95.2, R96.2, R98.2, R100.2, R110.2, R111.2, R112.2, R113.2, R114.2, R115.2, R116.2, R117.2, U18.3 (GND), U19.65 (GND), Y3.2 (GND); also elsewhere on the board
unnamed: C71.2, R67.1
unnamed: C90.2, R75.1, R82.1
unnamed: C91.2, R76.1, R83.1
unnamed: C92.2, R84.1, R86.1
unnamed: C93.1, R86.2, R89.1, R92.1
unnamed: C95.1, R87.2, R90.1
unnamed: C97.1, R93.2, R95.1, R99.1
unnamed: C98.2, R94.1, R96.1, R99.2
unnamed: C100.2, R100.1
unnamed: J26.1 (In), R77.1, R81.1
unnamed: C92.1, J27.1 (In), R78.1
unnamed: JP1.2 (B), U18.2 (NC)
unnamed: R82.2, R88.1, R93.1
unnamed: R83.2, R91.1, R94.2
unnamed: C80.1, R68.2, U18.1 (VC/OE/~ST)
unnamed: C94.1, U19.38 (CLKIN0_{N})
unnamed: C93.2, U19.37 (CLKIN0_{P})
unnamed: C96.1, U19.35 (CLKIN1_{N})
unnamed: C95.2, U19.34 (CLKIN1_{P})
unnamed: C99.1, C100.1, U19.46 (CP_{2})
unnamed: R102.2, U19.18 (CS_{n})
unnamed: C104.1, R110.1, U19.2 (DCLK0_{N})
unnamed: C103.1, R114.1, U19.1 (DCLK0_{P})
unnamed: C108.1, R112.1, U19.16 (DCLK2_{N})
unnamed: C107.1, R116.1, U19.15 (DCLK2_{P})
unnamed: C101.1, U19.11 (LDOBYP_{1})
unnamed: C102.1, U19.12 (LDOBYP_{2})
unnamed: R106.2, U19.31 (LD_{1})
unnamed: R107.2, U19.48 (LD_{2})
unnamed: R105.2, U19.5 (RESET)
unnamed: R103.2, U19.19 (SCK)
unnamed: C106.1, R111.1, U19.4 (SDCLK1_{N})
unnamed: C105.1, R115.1, U19.3 (SDCLK1_{P})
unnamed: C110.1, R113.1, U19.14 (SDCLK3_{N})
unnamed: C109.1, R117.1, U19.13 (SDCLK3_{P})
unnamed: R104.2, U19.20 (SDIO)
unnamed: R108.2, U19.58 (SEL_{0})
unnamed: R109.2, U19.59 (SEL_{1})
unnamed: R81.2, U19.6 (SYNC/SYSREFREQ)
unnamed: R85.1, R87.1, Y3.3 (OUT)

Notes on the sheet:
For ABLJO-V-160.000MHZ configure as LVCMOS (As drawn) For SiT502xAx-1 configure as LVPECL (See LMK DS) For SiT502xAx-2 configure as LVDS (See LMK DS)
XTAL
Loop Filter
LMK Termination
3dB Attenuator
XTAL Termination

Schematic: lmxmatchsingle.kicad_sch

Parts:
C25: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
C193, C194: 10n; C_0402_1005Metric; DIGIKEY_PN 1284-1540-1-ND
FB6: 470 OHM @ 100MHz; L_0402_1005Metric; DIGIKEY_PN 490-5198-1-ND
R222, R223, R225: 50; R_0402_1005Metric; DIGIKEY_PN FC0402-50BWCT-ND

Connections:
/Clocking/LMX Single Ended Matching A1/+3.3VA_LMXBUF: FB6.2; also elsewhere on the board
/Clocking/LMX Single Ended Matching A1/IN_{N}: C194.1, R223.2; also elsewhere on the board
/Clocking/LMX Single Ended Matching A1/IN_{P}: C193.1, R222.1; also elsewhere on the board
/Clocking/OUTPARAMP: C193.2; also elsewhere on the board
GND: C25.2, R225.2; also elsewhere on the board
unnamed: C25.1, FB6.1
unnamed: C25.3, R222.2, R223.1
unnamed: C194.2, R225.1

Parts of its further copies:
C68, C192: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
C231, C232, C234, C235: 10n; C_0402_1005Metric; DIGIKEY_PN 1284-1540-1-ND
FB7, FB8: 470 OHM @ 100MHz; L_0402_1005Metric; DIGIKEY_PN 490-5198-1-ND
R246, R247, R249, R250, R251, R253: 50; R_0402_1005Metric; DIGIKEY_PN FC0402-50BWCT-ND

Connections of its further copies:
/Clocking/LMX Single Ended Matching A/+3.3VA_LMXBUF: FB7.2, FB8.2; also elsewhere on the board
/Clocking/LMX Single Ended Matching A/IN_{N}: C232.1, R247.2; also elsewhere on the board
/Clocking/LMX Single Ended Matching A/IN_{P}: C231.1, R246.1; also elsewhere on the board
/Clocking/LMX Single Ended Matching B/IN_{N}: C235.1, R251.2; also elsewhere on the board
/Clocking/LMX Single Ended Matching B/IN_{P}: C234.1, R250.1; also elsewhere on the board
/RX_LO: C231.2; also elsewhere on the board
/TX_LO: C234.2; also elsewhere on the board
GND: C68.2, C192.2, R249.2, R253.2; also elsewhere on the board
unnamed: C68.1, FB7.1
unnamed: C68.3, R246.2, R247.1
unnamed: C192.1, FB8.1
unnamed: C192.3, R250.2, R251.1
unnamed: C232.2, R249.1
unnamed: C235.2, R253.1

Schematic: lmx2594.kicad_sch

Parts:
C111, C112: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
C113, C114, C121: 1u; C_0402_1005Metric
C115, C126, C134: 10u; C_0603_1608Metric; DIGIKEY_PN 490-10727-1-ND
C116, C118, C120, C125: 10u; C_0402_1005Metric
C117, C127, C136: 4.7u; C_1206_3216Metric; DIGIKEY_PN 490-GRM31CZ72A475ME11LCT-ND
C119, C128, C137: 100n; C_0402_1005Metric
C122, C123, C124, C129, C130, C138: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
C131: 2.2n; C_0402_1005Metric
C132: 180n; C_1206_3216Metric
C133: DNP; C_1206_3216Metric; not fitted
C135: 1.8n; C_0402_1005Metric
J28: SYSREFREQ; WR-MMCX_Wuerth_66012102111404_Vertical; not fitted
J29: TUNESENSE; SMA_Amphenol_132134-10_Vertical; DIGIKEY_PN ARF2755-ND
R118: 100; R_0402_1005Metric
R119, R134: 453k; R_0402_1005Metric; DIGIKEY_PN 13-RC0402FR-13453KLCT-ND
R120, R135: 33k; R_0402_1005Metric; DIGIKEY_PN YAG4374CT-ND
R121, R123, R124, R125, R126, R127, R128, R129, R130: 4.7k; R_0402_1005Metric; DIGIKEY_PN 311-4.7KJRCT-ND
R122: 49.9; R_0402_1005Metric
R131, R132: 180; R_0402_1005Metric
R133: DNP; R_0402_1005Metric; not fitted
R136: 0; R_0402_1005Metric
U20: LMX2594; VQFN-40-1EP_5x5mm_P0.4mm_EP3.3x3.3mm

Connections:
/Clocking/LMK04828/DCLK2n: C112.2, R118.2; also elsewhere on the board
/Clocking/LMK04828/DCLK2p: C111.1, R118.1; also elsewhere on the board
/Clocking/LMK04828/SDCLK3p: U20.5 (SYNC); also elsewhere on the board
/Clocking/LMX2594_PARAMP/+3.3VA_LMX: C115.1, C117.1, C119.1, C122.1, C123.1, C124.1, C126.1, C127.1, C128.1, C129.1, C130.1, R119.1; also elsewhere on the board
/Clocking/LMX2594_PARAMP/Linear POL LMX BUF/PGFB: R134.2; also elsewhere on the board
/Clocking/LMX2594_PARAMP/Linear POL LMX BUF/SET: R135.1; also elsewhere on the board
/Clocking/LMX2594_PARAMP/Linear POL LMX/PGFB: R119.2; also elsewhere on the board
/Clocking/LMX2594_PARAMP/Linear POL LMX/SET: R120.1; also elsewhere on the board
/Clocking/LMX2594_PARAMP/RAMPCLK: R129.1
/Clocking/LMX2594_PARAMP/RAMPDIR: R130.1
/Clocking/LMX2594_PARAMP/RFOUTB_{N}: U20.18 (RFOUTB_{N})
/Clocking/LMX2594_PARAMP/RFOUTB_{P}: U20.19 (RFOUTB_{P})
/Clocking/LMX2594_PARAMP/VCC_CP: C122.3, U20.11 (VCCCP)
/Clocking/LMX2594_PARAMP/VCC_DIG: C129.3, R121.2, R123.2, U20.7 (VCCDIG)
/Clocking/LMX2594_PARAMP/VCC_LMXBUF: C138.3, U20.21 (VCCBUF)
/Clocking/LMX2594_PARAMP/VCC_MASH: C130.3, U20.15 (VCCMASH)
/Clocking/LMX2594_PARAMP/VCC_VCO1: C123.3, U20.37 (VCCVCO1)
/Clocking/LMX2594_PARAMP/VCC_VCO2: C124.3, U20.26 (VCCVCO2)
/Clocking/LMX2594_PARAMP/VTUNE: C135.1, J29.1 (In), R136.2, U20.35 (VTUNE)
/Clocking/LMX Single Ended Matching A1/+3.3VA_LMXBUF: C134.1, C136.1, C137.1, C138.1, R134.1; also elsewhere on the board
/Clocking/LMX Single Ended Matching A1/IN_{N}: U20.22 (RFOUTA_{N}); also elsewhere on the board
/Clocking/LMX Single Ended Matching A1/IN_{P}: U20.23 (RFOUTA_{P}); also elsewhere on the board
/Clocking/LMXCE: R121.1, R124.1; also elsewhere on the board
/Clocking/MUXOUT: R128.1; also elsewhere on the board
/Clocking/~LMX_{LOCS}: R123.1, R125.1; also elsewhere on the board
/Recieve Chain/CIPO: R127.1; also elsewhere on the board
/Recieve Chain/SCK: R126.1; also elsewhere on the board
GND: C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C134.2, C135.2, C136.2, C137.2, C138.2, J28.2 (Ext), J29.2 (Ext), R120.2, R122.2, R131.2, R133.2, R135.2, U20.2 (GND), U20.4 (GND), U20.6 (GND), U20.13 (GND), U20.14 (GND), U20.25 (GND), U20.31 (GND), U20.34 (GND), U20.39 (GND), U20.40 (GND), U20.41 (GND); also elsewhere on the board
unnamed: C132.2, R131.1
unnamed: C133.1, R132.2, R136.1
unnamed: C133.2, R133.1
unnamed: J28.1 (In), R122.1, U20.28 (SYSREFREQ)
unnamed: R124.2, U20.1 (CE)
unnamed: C131.1, C132.1, R132.1, U20.12 (CPOUT)
unnamed: R125.2, U20.24 (CS_{n})
unnamed: R128.2, U20.20 (MUXOUT)
unnamed: C112.1, U20.9 (OSCIN_{N})
unnamed: C111.2, U20.8 (OSCIN_{P})
unnamed: R129.2, U20.30 (RAMPCLK)
unnamed: R130.2, U20.32 (RAMPDIR)
unnamed: R126.2, U20.16 (SCK)
unnamed: R127.2, U20.17 (SDI)
unnamed: C125.1, U20.33 (VBIASVARAC)
unnamed: C120.1, U20.3 (VBIASVCO1)
unnamed: C121.1, U20.27 (VBIASVCO2)
unnamed: C116.1, U20.36 (VREFVCO1)
unnamed: C118.1, U20.29 (VREFVCO2)
unnamed: C113.1, U20.10 (VREGIN)
unnamed: C114.1, U20.38 (VREGVCO)

Parts of its further copies:
C202, C203: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
C204, C205, C212: 1u; C_0402_1005Metric
C206, C217, C225: 10u; C_0603_1608Metric; DIGIKEY_PN 490-10727-1-ND
C207, C209, C211, C216: 10u; C_0402_1005Metric
C208, C218, C227: 4.7u; C_1206_3216Metric; DIGIKEY_PN 490-GRM31CZ72A475ME11LCT-ND
C210, C219, C228: 100n; C_0402_1005Metric
C213, C214, C215, C220, C221, C229: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
C222: 2.2n; C_0402_1005Metric
C223: 180n; C_1206_3216Metric
C224: DNP; C_1206_3216Metric; not fitted
C226: 1.8n; C_0402_1005Metric
J40: SYSREFREQ; WR-MMCX_Wuerth_66012102111404_Vertical; not fitted
J41: TUNESENSE; SMA_Amphenol_132134-10_Vertical; DIGIKEY_PN ARF2755-ND
R227: 100; R_0402_1005Metric
R228, R243: 453k; R_0402_1005Metric; DIGIKEY_PN 13-RC0402FR-13453KLCT-ND
R229, R244: 33k; R_0402_1005Metric; DIGIKEY_PN YAG4374CT-ND
R230, R232, R233, R234, R235, R236, R237, R238, R239: 4.7k; R_0402_1005Metric; DIGIKEY_PN 311-4.7KJRCT-ND
R231: 49.9; R_0402_1005Metric
R240, R241: 180; R_0402_1005Metric
R242: DNP; R_0402_1005Metric; not fitted
R245: 0; R_0402_1005Metric
U34: LMX2594; VQFN-40-1EP_5x5mm_P0.4mm_EP3.3x3.3mm

Connections of its further copies:
/Clocking/LMK04828/DCLK0n: C203.2, R227.2; also elsewhere on the board
/Clocking/LMK04828/DCLK0p: C202.1, R227.1; also elsewhere on the board
/Clocking/LMK04828/SDCLK1p: U34.5 (SYNC); also elsewhere on the board
/Clocking/LMX2594/+3.3VA_LMX: C206.1, C208.1, C210.1, C213.1, C214.1, C215.1, C217.1, C218.1, C219.1, C220.1, C221.1, R228.1; also elsewhere on the board
/Clocking/LMX2594/Linear POL LMX BUF/PGFB: R243.2; also elsewhere on the board
/Clocking/LMX2594/Linear POL LMX BUF/SET: R244.1; also elsewhere on the board
/Clocking/LMX2594/Linear POL LMX/PGFB: R228.2; also elsewhere on the board
/Clocking/LMX2594/Linear POL LMX/SET: R229.1; also elsewhere on the board
/Clocking/LMX2594/VCC_CP: C213.3, U34.11 (VCCCP)
/Clocking/LMX2594/VCC_DIG: C220.3, R230.2, R232.2, U34.7 (VCCDIG)
/Clocking/LMX2594/VCC_LMXBUF: C229.3, U34.21 (VCCBUF)
/Clocking/LMX2594/VCC_MASH: C221.3, U34.15 (VCCMASH)
/Clocking/LMX2594/VCC_VCO1: C214.3, U34.37 (VCCVCO1)
/Clocking/LMX2594/VCC_VCO2: C215.3, U34.26 (VCCVCO2)
/Clocking/LMX2594/VTUNE: C226.1, J41.1 (In), R245.2, U34.35 (VTUNE)
/Clocking/LMX Single Ended Matching A/+3.3VA_LMXBUF: C225.1, C227.1, C228.1, C229.1, R243.1; also elsewhere on the board
/Clocking/LMX Single Ended Matching A/IN_{N}: U34.22 (RFOUTA_{N}); also elsewhere on the board
/Clocking/LMX Single Ended Matching A/IN_{P}: U34.23 (RFOUTA_{P}); also elsewhere on the board
/Clocking/LMX Single Ended Matching B/IN_{N}: U34.18 (RFOUTB_{N}); also elsewhere on the board
/Clocking/LMX Single Ended Matching B/IN_{P}: U34.19 (RFOUTB_{P}); also elsewhere on the board
/Clocking/LMXCE: R230.1, R233.1; also elsewhere on the board
/Clocking/MUXOUT: R237.1; also elsewhere on the board
/Clocking/RAMPCLK: R238.1; also elsewhere on the board
/Clocking/RAMPDIR: R239.1; also elsewhere on the board
/Clocking/~LMXCS: R232.1, R234.1; also elsewhere on the board
/Recieve Chain/CIPO: R236.1; also elsewhere on the board
/Recieve Chain/SCK: R235.1; also elsewhere on the board
GND: C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C225.2, C226.2, C227.2, C228.2, C229.2, J40.2 (Ext), J41.2 (Ext), R229.2, R231.2, R240.2, R242.2, R244.2, U34.2 (GND), U34.4 (GND), U34.6 (GND), U34.13 (GND), U34.14 (GND), U34.25 (GND), U34.31 (GND), U34.34 (GND), U34.39 (GND), U34.40 (GND), U34.41 (GND); also elsewhere on the board
unnamed: C223.2, R240.1
unnamed: C224.1, R241.2, R245.1
unnamed: C224.2, R242.1
unnamed: J40.1 (In), R231.1, U34.28 (SYSREFREQ)
unnamed: R233.2, U34.1 (CE)
unnamed: C222.1, C223.1, R241.1, U34.12 (CPOUT)
unnamed: R234.2, U34.24 (CS_{n})
unnamed: R237.2, U34.20 (MUXOUT)
unnamed: C203.1, U34.9 (OSCIN_{N})
unnamed: C202.2, U34.8 (OSCIN_{P})
unnamed: R238.2, U34.30 (RAMPCLK)
unnamed: R239.2, U34.32 (RAMPDIR)
unnamed: R235.2, U34.16 (SCK)
unnamed: R236.2, U34.17 (SDI)
unnamed: C216.1, U34.33 (VBIASVARAC)
unnamed: C211.1, U34.3 (VBIASVCO1)
unnamed: C212.1, U34.27 (VBIASVCO2)
unnamed: C207.1, U34.36 (VREFVCO1)
unnamed: C209.1, U34.29 (VREFVCO2)
unnamed: C204.1, U34.10 (VREGIN)
unnamed: C205.1, U34.38 (VREGVCO)

Schematic: house.kicad_sch

Parts:
C195: 2.2u; C_0805_2012Metric; DIGIKEY_PN 490-GRM21BD72A225ME01KCT-ND
C196: 220n; C_0402_1005Metric; DIGIKEY_PN 490-GRM155R61J224ME01JCT-ND
C197: 1u; C_0402_1005Metric; DIGIKEY_PN 490-14409-1-ND
C198: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
C199, C200, C201: 22u; C_0603_1608Metric; DIGIKEY_PN 490-14659-1-ND
L5: 22u; L_Bourns_SRN6045TA; DIGIKEY_PN SRN6045-220MCT-ND
R226: 100k; R_0402_1005Metric; DIGIKEY_PN YAG2304CT-ND
U33: LMR36510ADDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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; DIGIKEY_PN 296-LMR36510ADDARCT-ND

Connections:
+VDC: C195.1, C196.1, U33.2 (VIN), U33.3 (EN); also elsewhere on the board
/MCU/MCU Power/FB: R226.1, U33.5 (FB); also elsewhere on the board
/MCU/MCU Power/PG: U33.4 (PG)
/MCU/MCU Power/VOUT: C199.1, C200.1, C201.1, L5.2, R226.2; also elsewhere on the board
GND: C195.2, C196.2, C197.2, C199.2, C200.2, C201.2, U33.1 (PGND), U33.9 (PAD); also elsewhere on the board
unnamed: C198.1, U33.7 (BOOT)
unnamed: C198.2, L5.1, U33.8 (SW)
unnamed: C197.1, U33.6 (VCC)

Notes on the sheet:
2.2u 100V 0805 X7T GRM21BD72A225ME01K
22u 6.3V 0805 X7T GRM21BD70J226ME44L
22uH 1.9A ISAT SRN6045-220M
0.22u 63V 0402 X5R GRM155R61J224ME01J

Schematic: hmc788.kicad_sch

Parts:
C5, C6: 1n; C_0201_0603Metric
C7, C233: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
FB1: 470 OHM @ 100MHz; L_0402_1005Metric; DIGIKEY_PN 490-5198-1-ND
U8: HMC788A; LFCSP-6-1EP_2x2mm_P0.65mm_EP1x1.6mm

Connections:
/Monitor Path/COMMON: C5.2; also elsewhere on the board
/Monitor Path/HMC788A/RF_{OUT}: C6.1; also elsewhere on the board
/VCC_LODRIVE: C233.3; also elsewhere on the board
GND: C7.2, C233.2, U8.1 (NC), U8.3 (GND), U8.4 (NC), U8.6 (NC), U8.7 (GND); also elsewhere on the board
unnamed: C7.1, FB1.1
unnamed: C233.1, FB1.2
unnamed: C5.1, U8.2 (RF_{IN})
unnamed: C6.2, C7.3, U8.5 (RF_{OUT})

Parts of its further copies:
C8, C67, C276, C277: 1u; NFM18PS; DIGIKEY_PN 490-13394-1-ND
C65, C66, C274, C275: 1n; C_0201_0603Metric
FB2, FB5: 470 OHM @ 100MHz; L_0402_1005Metric; DIGIKEY_PN 490-5198-1-ND
U17, U44: HMC788A; LFCSP-6-1EP_2x2mm_P0.65mm_EP1x1.6mm

Connections of its further copies:
/RX Mixer/HMC788A/RF_{OUT}: C275.1; also elsewhere on the board
/RX_LO: C274.2; also elsewhere on the board
/TX Mixer/HMC788A/RF_{OUT}: C66.1; also elsewhere on the board
/TX_LO: C65.2; also elsewhere on the board
/VCC_LODRIVE: C276.3, C277.3; also elsewhere on the board
GND: C8.2, C67.2, C276.2, C277.2, U17.1 (NC), U17.3 (GND), U17.4 (NC), U17.6 (NC), U17.7 (GND), U44.1 (NC), U44.3 (GND), U44.4 (NC), U44.6 (NC), U44.7 (GND); also elsewhere on the board
unnamed: C8.1, FB2.1
unnamed: C67.1, FB5.1
unnamed: C276.1, FB2.2
unnamed: C277.1, FB5.2
unnamed: C65.1, U17.2 (RF_{IN})
unnamed: C8.3, C66.2, U17.5 (RF_{OUT})
unnamed: C274.1, U44.2 (RF_{IN})
unnamed: C67.3, C275.2, U44.5 (RF_{OUT})

Schematic: lf_balun_output.kicad_sch

Parts:
C139, C140, C141: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
R137, R140, R145, R146: 0; R_0402_1005Metric; not fitted
R138, R139, R143, R144: 49.9; R_0402_1005Metric
R141: 560; R_0402_1005Metric; not fitted
R142: 100; R_0402_1005Metric; not fitted
TR1: ADT2-1T+; Mini-Circuits_CD637_H5.23mm

Connections:
/Clocking/LMK04828/+3.3VA_LMKCGVCO: R140.2; also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 9/C+: C139.1, R138.1, R141.1; also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 9/C-: C140.2, R139.2, R141.2; also elsewhere on the board
/SYNCOUT_{n}: R146.2, TR1.1; also elsewhere on the board
/SYNCOUT_{p}: C141.2; also elsewhere on the board
GND: R137.1, R143.2, R144.2, R145.1, R146.1; also elsewhere on the board
unnamed: C139.2, R142.1, R143.1, TR1.4
unnamed: C140.1, R142.2, R144.1, TR1.6
unnamed: C141.1, TR1.3
unnamed: R137.2, R138.2, R139.1, R140.1
unnamed: R145.2, TR1.5

Parts of its further copies:
C146, C147, C148, C149, C150, C151: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
R160, R163, R168, R169, R170, R173, R178, R179: 0; R_0402_1005Metric; not fitted
R161, R162, R166, R167, R171, R172, R176, R177: 49.9; R_0402_1005Metric
R164, R174: 560; R_0402_1005Metric; not fitted
R165, R175: 100; R_0402_1005Metric; not fitted
TR2, TR3: ADT2-1T+; Mini-Circuits_CD637_H5.23mm

Connections of its further copies:
/Clocking/LMK04828/+3.3VA_LMKCGVCO: R163.2, R173.2; also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 10/C+: C146.1, R161.1, R164.1; also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 10/C-: C147.2, R162.2, R164.2; also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 11/C+: C149.1, R171.1, R174.1; also elsewhere on the board
/Clocking/LMK04828/LF Balun Output 11/C-: C150.2, R172.2, R174.2; also elsewhere on the board
/PPSOUT_{n}: R179.2, TR3.1; also elsewhere on the board
/PPSOUT_{p}: C151.2; also elsewhere on the board
/REFOUT_{n}: R169.2, TR2.1; also elsewhere on the board
/REFOUT_{p}: C148.2; also elsewhere on the board
GND: R160.1, R166.2, R167.2, R168.1, R169.1, R170.1, R176.2, R177.2, R178.1, R179.1; also elsewhere on the board
unnamed: C146.2, R165.1, R166.1, TR2.4
unnamed: C147.1, R165.2, R167.1, TR2.6
unnamed: C148.1, TR2.3
unnamed: C149.2, R175.1, R176.1, TR3.4
unnamed: C150.1, R175.2, R177.1, TR3.6
unnamed: C151.1, TR3.3
unnamed: R160.2, R161.2, R162.1, R163.1
unnamed: R168.2, TR2.5
unnamed: R170.2, R171.2, R172.1, R173.1
unnamed: R178.2, TR3.5

Schematic: hf_output.kicad_sch

Parts:
C152, C153: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
J31: MMCX_P
J32: MMCX_N
R180, R181: 240; R_0402_1005Metric
R182: 100; R_0402_1005Metric
R183, R184: 49.9; R_0402_1005Metric; not fitted

Connections:
/Clocking/LMK04828/HF Out 2/C+: C152.1, R181.1, R182.1; also elsewhere on the board
/Clocking/LMK04828/HF Out 2/C-: C153.2, R180.1, R182.2; also elsewhere on the board
GND: J31.2 (Ext), J32.2 (Ext), R180.2, R181.2, R183.2, R184.2; also elsewhere on the board
unnamed: C152.2, J31.1 (In), R183.1
unnamed: C153.1, J32.1 (In), R184.1

Parts of its further copies:
C158, C159: 100n; C_0402_1005Metric; DIGIKEY_PN 490-14603-1-ND
J34: MMCX_P
J35: MMCX_N
R188, R189: 240; R_0402_1005Metric
R190: 100; R_0402_1005Metric
R191, R192: 49.9; R_0402_1005Metric; not fitted

Connections of its further copies:
/Clocking/LMK04828/HF Out 3/C+: C158.1, R189.1, R190.1; also elsewhere on the board
/Clocking/LMK04828/HF Out 3/C-: C159.2, R188.1, R190.2; also elsewhere on the board
GND: J34.2 (Ext), J35.2 (Ext), R188.2, R189.2, R191.2, R192.2; also elsewhere on the board
unnamed: C158.2, J34.1 (In), R191.1
unnamed: C159.1, J35.1 (In), R192.1

Board: 6 copper layers, 739 parts (0 on the bottom side), 487 nets, no tracks yet.
